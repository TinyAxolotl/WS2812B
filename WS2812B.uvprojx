# Keil uVision project WS2812B.uvprojx, settings and files
target WS2812 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: WS2812B +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CMSIS\inc;.\CMSIS\src;.\Code\inc;.\Code\src;.\Startup;.\SPL
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group CMSIS
    ./CMSIS/inc/: stm32f30x.h system_stm32f30x.h core_cm4.h
    ./CMSIS/src/: system_stm32f30x.c
  group Code
    ./Code/src/: main.c
    ./Code/inc/: main.h
  group Startup
    ./Startup/: startup_stm32f303xc.s
  group SPL
    ./SPL/: stm32f30x_conf.h stm32f30x_dma.c stm32f30x_gpio.c stm32f30x_rcc.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c
